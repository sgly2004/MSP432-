# Keil uVision project MSP432.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSP432
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\sys;..\sys\driverlib\MSP432P4xx;..\sys\inc;..\sys\rom\MSP432P4xx;..\ml_libs;..\code;..\sys\inc\CMSIS;..\sys\start_up
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group user
    ./: main.c isr.c
  group code
    ../code/: motor.c motor.h pid.c pid.h
  group sys
    ../sys/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
    ../sys/start_up/: startup_msp432p401r_uvision.s system_msp432p401r.c
    ../sys/driverlib/MSP432P4xx/: interrupt.c
  group ml_libs
    ../ml_libs/: headfile.h ml_gpio.c ml_gpio.h ml_delay.c ml_delay.h ml_oled.c ml_oled.h ml_oled_font.h ml_tim.c ml_tim.h ml_pwm.c ml_pwm.h ml_uart.c ml_uart.h ml_exti.c ml_exti.h ml_mpu6050.c ml_mpu6050.h ml_i2c.c ml_i2c.h ml_hmc5883l.c ml_hmc5883l.h
